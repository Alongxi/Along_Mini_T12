# Keil uVision project Mini_T12_Demo.uvproj, settings and files
target IIC_OLED (MCS-51)
  device: STC8G2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Mini_T12_Demo +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\Libraries\libraries;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\USER\inc;..\USER\src;..\..\Libraries\GUI;..\..\Libraries\User;..\..\Libraries\User_lib
  group startup
    ../../Libraries/libraries/: common.c common.h STC8Gxx.h board.c board.h
  group Libraries
    ../../Libraries/seekfree_libraries/: zf_iic.c zf_uart.c zf_adc.c zf_tim.c zf_pwm.c zf_pca_pit.c zf_exti.c zf_pca_delay.c zf_gpio.c zf_eeprom.c
  group Peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_FONT.c SEEKFREE_IIC.c SEEKFREE_MPU6050.c
  group MAIN
    ../USER/src/: isr.c main.c
    ../使用说明/: 使用说明.txt
  group GUI
    ../../Libraries/GUI/: user_menu.c
  group USER
    ../../Libraries/User/: user_adc.c user_pid.c user_button.c user_eeprom.c
  group USER_LIB
    ../../Libraries/User_lib/: user_lib_iic.c
